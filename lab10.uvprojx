# Keil uVision project lab10.uvprojx, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab10
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./startup/: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./source/: lab10.c timer.c
target LPC1768 RAM (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC1768 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.0.1
